IMAGE_INSTALL:append:imx8mp-var-dart = " v4l2-test test.sh"
IMAGE_INSTALL:append:imx95-var-dart = " v4l2-test test95.sh"