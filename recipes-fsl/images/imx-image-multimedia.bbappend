# DTBs aus deploy in die Boot-Partition übernehmen (src;dst)
IMAGE_BOOT_FILES:append = " \
    lec-imx8mp-vc-mipi-isi-csi0.dtb \
    lec-imx8mp-vc-mipi-isi-csi1.dtb \
    lec-imx8mp-vc-mipi-isi-csi0-csi1.dtb \
    lec-imx8mp-vc-mipi-isp-csi0.dtb \
    lec-imx8mp-vc-mipi-isp-csi0-csi1.dtb \
"